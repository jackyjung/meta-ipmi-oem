IMAGE_INSTALL:append = " ipmitool phosphor-ipmi-host ves-oem-ipmi phosphor-ipmi-net"
